Properties of the parts of a building model (IFC4)

# File
Description: Universalkapillar-Doppelthermostat, TW 0…120 °C, TB 20…150 °C, Hysterese TW = 3 K TB = -10…-15 K, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA001200, Universalkapillar-Doppelthermostat, TW 0…120 °C, TB 20…150 °C, Hysterese TW = 3 K TB = -10…-15 K
In: Raum
Description: Diese Gerätereihe wurde speziell entwickelt für den Einsatz in der Heiztechnik in Kesselanlagen oder Speichern, Fernwärmeübergabestationen und Wärmeübertragungsanlagen, in der Lüftungstechnik als Zuluftüberwachung oder als Begrenzer von elektrischen Heizregistern. Tauchhülsen/Schutzwendel gehören nicht zum Lieferumfang. In Verbindung mit Tauchhülsen oder Schutzwendeln ist das Zubehör JZ-30 zu verwenden. Der Regelbereich / Hysterese beträgt beim Temperaturwächter 0…120 °C / 3 K und beim Temperaturbegrenzer 20…150 °C / -10…-15 K.; Classification: EC011173 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA001200; ModelLabel: RTKSA-013.210; GlobalTradeItemNumber: 4050528074744; ProductURL: https://alre.de/produkt_KA001200
Pset_Specification - NominalLength: 0.1468 m; NominalWidth: 0.106 m; NominalDepth: 0.0629 m; NetWeight: 0.487
Pset_ALRE_ETIM_Properties - Breite: 106; Höhe: 146.8; Tiefe: 62.9; Messbereich: 0; Explosionsgeschützt: no; Schutzart (IP): IP54; Ausführung Aufnehmer/Fühler: kapillar; Max. Mediumtemperatur (Dauerbetrieb): 138; Max. Spannung der Kontakte: 230; Kontaktverriegelung: yes; Max. Kontaktbelastung: 16; Differenzwert: 3; Differenz verstellbar: no; ETIM-Klasse: EC011173; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA001200.pdf
